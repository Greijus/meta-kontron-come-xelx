# Turbostat depends on libcap starting from linux-5.4.31
DEPENDS += "libcap"
